<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>atsc_pad</key>
<param><key>id</key><value>atsc_pad_0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>(4500000.0 / 286 * 684) * 3</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>1024</value></param>
</block>
<block>
<key>atsc_field_sync_mux</key>
<param><key>id</key><value>atsc_field_sync_mux_0</value></param>
</block>
<block>
<key>atsc_trellis_encoder</key>
<param><key>id</key><value>atsc_trellis_encoder_0</value></param>
</block>
<block>
<key>atsc_interleaver</key>
<param><key>id</key><value>atsc_interleaver_0</value></param>
</block>
<block>
<key>atsc_random</key>
<param><key>id</key><value>atsc_random_0</value></param>
</block>
<block>
<key>atsc_rs_encoder</key>
<param><key>id</key><value>atsc_rs_encoder_0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>vga1_gain</value></param>
<param><key>label</key><value>VGA1 Gain</value></param>
<param><key>value</key><value>-8</value></param>
<param><key>min</key><value>-35</value></param>
<param><key>max</key><value>-4</value></param>
<param><key>num_steps</key><value>31</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>m</key><value>832</value></param>
<param><key>n</key><value>1024</value></param>
<param><key>offset</key><value>4</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/re/xfer/glitchatsc.ts</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>atscmap_atscmap_bc</key>
<param><key>id</key><value>atscmap_atscmap_bc_0</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sample_rate</key><value>symbol_rate </value></param>
<param><key>freq0</key><value>429000000</value></param>
<param><key>gain0</key><value>vga2_gain</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>bb_gain0</key><value>vga1_gain</value></param>
<param><key>bw0</key><value>6000000</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>vga2_gain</value></param>
<param><key>label</key><value>VGA2 Gain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>25</value></param>
<param><key>num_steps</key><value>25</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>atsc_blade_fpga</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>atsc_pad_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>atsc_pad_0</source_block_id><sink_block_id>atsc_random_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>atsc_random_0</source_block_id><sink_block_id>atsc_rs_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>atsc_rs_encoder_0</source_block_id><sink_block_id>atsc_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>atsc_interleaver_0</source_block_id><sink_block_id>atsc_trellis_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>atsc_trellis_encoder_0</source_block_id><sink_block_id>atsc_field_sync_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>atsc_field_sync_mux_0</source_block_id><sink_block_id>blocks_vector_to_stream_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_1</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>atscmap_atscmap_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>atscmap_atscmap_bc_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
